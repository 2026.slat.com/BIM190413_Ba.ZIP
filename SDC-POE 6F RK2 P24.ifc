Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2019-07-10T15:25:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 10 15:25:40 2019 * Host: DESKTOP-AJHKH4T * Database: C:\Users\xingo\AppData\Local\Temp\{6005C1AE-69D9-43EE-B3BA-357AF2095775}\ifc * Database version: 5507 * Database creation date: Wed Jul 10 15:25:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 10 15:25:39 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 10 15:25:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: RACK 2U 24P - SDC-POE 6F 6F RK2 P24 (SLAT), RACK 2U 24P:RACK 2U 24P - SDC-POE 6F 6F RK2 P24 (SLAT):137830
In: Niveau 1
Type - Autre - Catégorie: Equipement électrique; datBIM.Classe electrique (Electrical class): 1; datBIM.Code datBIM entité: 83962307; datBIM.Code produit SLAT (Id SlatEntityCode): 83962307; datBIM.Conformite ATEX (ATEX compliance): Non (No); datBIM.Consommation electrique (Primary current): 1,4; datBIM.Couleur dominante (Dominant color): Blanc (White); datBIM.Courant maximal d'utilisation (Maximal output current): 3,8; datBIM.Degre d'etancheite IP (Protection class IP): IP30; datBIM.Description longue entité: <p> <img title="SDC-PoE24_front-view_HD.jpg" src="https://admin.datbim.com/media/mid/1/23228.jpg" alt="" width="251" height="111" data-idmedia="23228" /></p><p><em>Ref. : 83962307<br /></em></p><p>SDC-PoE24 est un Switch PoE/PoE+ manageable layer 2+, 24 Ports avec fonction Micro-UPS DC intégré (batterie LiFePO4). Avec 24 ports en full-Gigabit dont 4 SFP pour les liaisons fibres, le switch raccorde et alimente les équipements connectés, tels que les caméras, enregistreurs, centrales d?alarme, etc? Il gère leurs flux de données et surveille le bon fonctionnement des équipements.<br /> En cas de coupure de courant, il assure la continuité de service, et le maintien opérationnel des équipements alimentés en PoE/PoE+ / SDC-PoE24 is a manageable layer 2+, 24-port PoE/PoE+ switch with integrated DC Micro-UPS function (LiFePO4 battery). With 24 full-Gigabit ports, including 4 SFP ports for fiber connections, the switch connects and powers connected equipment, such as cameras, recorders, alarm systems, etc. It manages their data flows and monitors the proper functioning of the equipment.<br /> In the event of a power failure, it ensures the continuity of service and the operational maintenance of equipment powered by PoE/PoE+.</p>; datBIM.Designation technique (Technical designation): AES, EAE, EAES; datBIM.Duree de la garantie (Length of warranty): 3 ans; datBIM.Duree de vie previsionnelle (Expected life expectancy): 10 ans; datBIM.Duree de vie previsionnelle de reconditionnement (Expected life of refurbishment): 10 ans; datBIM.Fonction generique (Generic function): Switch secourue (Emergency switch); datBIM.Hauteur (Height): 85.6 mm; datBIM.Hauteur hors tout (Height overall): 89.9 mm; datBIM.Id: datBIM:385250; datBIM.Largeur (Wide): 443 mm; datBIM.Largeur hors tout (Wide overall): 443 mm; datBIM.Libellé entité: SDC-POE 6F 6F RK2 P24; datBIM.Longueur (Length): 390 mm; datBIM.Longueur hors tout (Length overall): 390 mm; datBIM.Marque commerciale (Commercial brand): SLAT; datBIM.Matiere de l'enveloppe (Envelope material): Acier (Steel); datBIM.Mode de communication (Communication mode): 20 Ports Ethernet 10_100_1000 Mbps + 2 Port SFP 100_1000 Mbps + 2 ports Combo Ethernet_SFP (20 Ethernet ports 10_100_1000 Mbps + 2 SFP ports 100_1000 Mbps + 2 Ethernet Combo ports _SFP); datBIM.Nombre de sorties d'alimentation (Number of power supply outputs): 22; datBIM.Poids (Weight): 7; datBIM.Point de fixation (Mounting point): 4; datBIM.Produit repartis dans plusieurs enveloppes (Product divided into several envelopes): Non (No); datBIM.Puissance (Output power): 210 W; datBIM.Qualification d'installateur : NF S 61-932 - Règles d’installation (Installer qualification : NF S 61-932 - Installation rules): Recommande (Recommanded); datBIM.Qualification d'installateur : NF S 61-970 - Règles d'installation des systèmes de détection incendie (Installer qualification : Installation rules for fire detection systems): Recommande (Recommanded); datBIM.Qualification d'installateur : R7 (Installer qualification : R7): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe B NF S 61-933 - SDI (Qualification of the maintainer : Appendix B NF S 61-933 - SDI): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe J NF S 61-933 Alimentation (Qualification of the maintainer : Appendix J NF S 61-933 Power supply): Recommande (Recommanded); datBIM.Qualification du mainteneur : Annexe L NF S 61-933 Exploitant (Qualification of the maintainer : Appendix L NF S 61-933 Operator): Recommande (Recommanded); datBIM.Rendement energetique (Energy efficiency): 78; datBIM.Substance visee par REACH_DEEE (Substance covered by REACH_DEEE): Non (No); datBIM.Temperature d'utilisation (Operating temperature): -10 à +45 °C; datBIM.Tension de fonctionnement [Min-Max] (Mains voltage [Min-Max]): 195,5-264,5 V; datBIM.Tension nominale de sortie (Rated output voltage): 55 V; datBIM.Type de liaison (Type of link): Filaire (Wired); datBIM.Type d'installation (Mounting type): Baie - A poser (Bay-mounted - Floor-mounted); Nom de la famille: RACK 2U 24P
Type - Cotes - Diamètre orifice: 9 mm; Distance entre ports: 12 mm; Distance horizontale ouverture: 2.9 mm; Distance p: 8 mm; Distance ports bas: 13.5 mm; Distance ports droite: 44 mm; Distance ports gauche: 152 mm; Distance ports haut: 40 mm; Epaisseur: 80 mm; Epaisseur équerre: 1 mm; Hauteur équerre: 85 mm; Largeur: 440 mm; Largeur équerre: 60 mm; Longeur: 364 mm; Longueur équerre: 18 mm
Type - Données d'identification - Fabricant: SLAT; Nom du type: RACK 2U 24P - SDC-POE 6F 6F RK2 P24 (SLAT); Numéro OmniClass: 23.80.30.11.17; Titre OmniClass: Distribution Boards and Control Panels
Pset_BuildingElementProxyCommon - Reference: RACK 2U 24P - SDC-POE 6F 6F RK2 P24 (SLAT)
Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Autre - Famille: RACK 2U 24P: RACK 2U 24P - SDC-POE 6F 6F RK2 P24 (SLAT); Famille et type: RACK 2U 24P: RACK 2U 24P - SDC-POE 6F 6F RK2 P24 (SLAT); ID du type: RACK 2U 24P: RACK 2U 24P - SDC-POE 6F 6F RK2 P24 (SLAT); Type: RACK 2U 24P: RACK 2U 24P - SDC-POE 6F 6F RK2 P24 (SLAT)
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.24618 m2; Volume: 0.0128383 m3
Données d'identification - Identifiant: 1
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Phase 1
